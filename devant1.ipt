# Autodesk Inventor part: devant1_Dfaut
## iProperties
Created: 2007-07
Part Number: devant1_Dfaut
Document SubType Name: Modeling
Designer: EF
Density: 1 g/cm^3
Author: EF
## Feature names
1. Base1
