# Autodesk Inventor part: verrou_Dfaut
## iProperties
Created: 2007-07
Part Number: verrou_Dfaut
Document SubType Name: Modeling
Designer: EF
Density: 1 g/cm^3
Author: EF
## Feature names
1. Base1
