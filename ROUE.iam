# Autodesk Inventor assembly: ROUE
## iProperties
Created: 2007-07
Part Number: ROUE
Document SubType Name: Assembly
Designer: EF
Author: EF
