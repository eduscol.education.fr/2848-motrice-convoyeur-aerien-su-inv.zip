# Autodesk Inventor assembly: Tigeelectro
## iProperties
Created: 2007-07
Part Number: Tigeelectro
Document SubType Name: Assembly
Designer: EF
Author: EF
