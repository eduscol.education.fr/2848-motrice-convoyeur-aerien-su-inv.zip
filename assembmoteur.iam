# Autodesk Inventor assembly: assembmoteur_Dfaut
## iProperties
Created: 2007-07
Part Number: assembmoteur_Dfaut
Document SubType Name: Assembly
Designer: EF
Author: EF
