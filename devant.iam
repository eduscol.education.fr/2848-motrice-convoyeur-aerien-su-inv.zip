# Autodesk Inventor assembly: devant_Dfaut
## iProperties
Created: 2007-07
Part Number: devant_Dfaut
Document SubType Name: Assembly
Designer: EF
Author: EF
