# Autodesk Inventor assembly: verrou
## iProperties
Created: 2007-07
Part Number: verrou
Document SubType Name: Assembly
Designer: EF
Author: EF
