# Autodesk Inventor assembly: mecanisme verrou ver bruay_Dfaut
## iProperties
Created: 2007-07
Part Number: mecanisme verrou ver bruay_Dfaut
Document SubType Name: Assembly
Designer: EF
Author: EF
