# Autodesk Inventor assembly: Chassis motrice
## iProperties
Created: 2007-07
Part Number: Chassis motrice
Document SubType Name: Assembly
Designer: EF
Author: EF
